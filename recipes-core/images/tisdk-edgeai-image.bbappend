EDGEAI_STACK:remove:beagley-ai = "ti-edgeai-firmware"
EDGEAI_STACK:append:beagley-ai = " ti-edgeai-firmware-beagley"
