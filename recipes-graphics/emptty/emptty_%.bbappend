# The dual-display application owns the DRM outputs.
SYSTEMD_AUTO_ENABLE:${PN}:beagley-ai = "disable"
