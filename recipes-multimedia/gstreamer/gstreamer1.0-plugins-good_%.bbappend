FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:beagley-ai = " file://0001-v4l2-j721e-use-eight-buffers.patch"
