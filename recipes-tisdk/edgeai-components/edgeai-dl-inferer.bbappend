FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:beagley-ai = " file://0001-onnx-use-tidl-option-api.patch"
