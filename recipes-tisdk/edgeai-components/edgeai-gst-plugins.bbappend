FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:beagley-ai = " file://0003-enable-j722s-tiovxisp.patch"
SRC_URI:append:beagley-ai = " file://0006-skip-ti-2a-when-disabled.patch"
SRC_URI:append:beagley-ai = " file://0007-zero-copy-dmabuf-import.patch"
SRC_URI:append:beagley-ai = " file://0008-add-ox03h10-ae-controls.patch"
SRC_URI:append:beagley-ai = " file://0009-ox03h10-sensor-pre-wb.patch"
