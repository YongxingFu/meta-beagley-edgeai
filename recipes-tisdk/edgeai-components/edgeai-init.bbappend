# Keep the package available, but do not start the Edge AI GUI on this board.
SYSTEMD_AUTO_ENABLE:${PN}:beagley-ai = "disable"
