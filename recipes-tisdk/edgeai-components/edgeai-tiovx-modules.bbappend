FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:beagley-ai = " file://0004-add-ox03h10-dcc-id.patch"
SRC_URI:append:beagley-ai = " file://0005-j722s-viss-free-shared-heap.patch"
