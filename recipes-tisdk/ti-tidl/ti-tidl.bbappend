FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:beagley-ai = " file://0001-tidl-quiet-shared-memory-eligibility.patch"
